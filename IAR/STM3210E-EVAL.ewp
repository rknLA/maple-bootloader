# IAR project STM3210E-EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCIncludePath2: ..\stm32_lib\; ..\usb_lib\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkOutputFile: STM3210E-EVAL.out
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: common.h config.h dfu.c dfu.h hardware.c hardware.h main.c usb.c usb.h usb_callbacks.c usb_descriptor.c usb_descriptor.h
  group stm_lib
    ../stm32_lib/: c_only_startup.s c_only_startup_user.s cortexm3_macro.h cortexm3_macro.s stm32f10x_type.h
  group usb_lib
    ../usb_lib/: usb_conf.h usb_core.c usb_core.h usb_def.h usb_init.c usb_init.h usb_int.c usb_int.h usb_lib.h usb_mem.c usb_mem.h usb_regs.c usb_regs.h usb_type.h
